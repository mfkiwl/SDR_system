options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: EBW
  id: variable
  parameters:
    value: '350e-3'
  states: {}
- name: QPSK
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: RRC_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: EBW
    gain: nfilts
    ntaps: 5*sps_TX*nfilts
    samp_rate: nfilts
    sym_rate: '1'
  states: {}
- name: SNR
  id: variable_qtgui_range
  parameters:
    gui_hint: 18,0
    label: SNR[dB]
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '30'
    value: '30'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Delay
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '400'
    value: '86'
  states: {}
- name: freq_dev
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0
    orient: Qt.Horizontal
    start: '-20e3'
    step: '1'
    stop: 20e3
    value: '0'
  states: {}
- name: freq_offset_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,0
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: freq_offset_value
  id: variable
  parameters:
    value: 30e3
  states: {}
- name: len_vect
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,0
    label: Noise Voltage
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0001'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps_RX), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 76.8e3*20
  states: {}
- name: sps_RX
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_TX
  id: variable
  parameters:
    value: 40*2
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: time_offset_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,0
    label: Timing Offset
    orient: Qt.Horizontal
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: analog_feedforward_agc_cc_1
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '512'
    reference: '1.0'
  states: {}
- name: analog_pwr_squelch_xx_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.01'
    gate: 'True'
    ramp: '0'
    threshold: '-20'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-freq_offset_value'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: byte
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/artiom/Shared/SDR_system-main/SDR_analis/data.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: 76800*20
    max_iter: 76800*20
    scale: 0.000013021/20
    type: float
  states: {}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: 76800*20
    max_iter: 76800*20
    scale: 0.000013021/20
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.3'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: len_vect
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: len_vect
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: len_vect
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: len_vect
    type: byte
  states: {}
- name: blocks_streams_to_vector_1
  id: blocks_streams_to_vector
  parameters:
    type: byte
    vlen: len_vect
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/sps_TX
    type: byte
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_udp_sink_1
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '40869'
    psize: 1472*2
    type: byte
    vlen: len_vect*2
  states: {}
- name: blocks_udp_sink_1_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '40870'
    psize: '1472'
    type: byte
    vlen: len_vect
  states: {}
- name: blocks_udp_sink_1_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '40871'
    psize: '1472'
    type: byte
    vlen: len_vect
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset_0
    freq_offset: freq_offset_0
    noise_voltage: noise_volt_0
    seed: '0'
    taps: taps
  states: {state: bypassed}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset_0
    freq_offset: freq_offset_0
    noise_voltage: noise_volt_0
    seed: '0'
    taps: taps
  states: {state: bypassed}
- name: channels_channel_model_0_1
  id: channels_channel_model
  parameters:
    epsilon: time_offset_0
    freq_offset: freq_offset_0
    noise_voltage: 1/(10**(SNR/20))
    seed: '0'
    taps: taps
  states: {}
- name: channels_channel_model_0_1_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset_0
    freq_offset: freq_offset_0
    noise_voltage: 1/(10**(SNR/20))
    seed: '0'
    taps: taps
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: '10e-3'
    num_taps: '11'
    sps: '1'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps_TX
  states: {}
- name: digital_costas_loop_cc_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '10e-3'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_1
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: EBW
    samps_per_sym: sps_RX
    type: cc
    w: '0.02'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_1
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/400*2
    max_dev: '1.5'
    osps: '1'
    sps: sps_RX
    taps: rrc_taps
    type: ccf
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: center_freq+freq_offset_value
    gain0: '30'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 16,0
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 17,0
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3, 0
    max: '0'
    min: '-10'
    name: '"Error"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 19,0
    name: '"Power_signal"'
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 20,0
    name: '"Power_noise"'
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 22,0
    name: '"SNR[dB]"'
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/20
    fc: '0'
    fftsize: '1024'
    gui_hint: 6,0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 4,0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2, 0
    label1: Rx Bits
    label2: Diff
    label3: Tx Bits
    name: ''
    nconnections: '3'
    size: '512'
    srate: samp_rate/80
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(sps_TX/sps_RX)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    dc_offset_mode0: '2'
    freq0: center_freq+freq_dev-9007
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '0'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rc
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rc
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: byte_in
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: byte_out
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: noise
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rc
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: byte_out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: byte_in
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: rc
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: noise
  states: {}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: noise
  states: {}

connections:
- [analog_feedforward_agc_cc_1, '0', digital_pfb_clock_sync_xxx_1, '0']
- [analog_pwr_squelch_xx_1, '0', digital_fll_band_edge_cc_1, '0']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0_0_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', digital_binary_slicer_fb_0_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_moving_average_xx_1, '0']
- [blocks_complex_to_mag_squared_1_0, '0', blocks_moving_average_xx_1_0, '0']
- [blocks_delay_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_delay_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_divide_xx_0, '0']
- [blocks_moving_average_xx_1, '0', qtgui_number_sink_0_0, '0']
- [blocks_moving_average_xx_1_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_multiply_const_xx_1, '0', qtgui_number_sink_0_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0_0, '0', virtual_sink_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_multiply_const_xx_1, '0']
- [blocks_null_source_0, '0', blocks_throttle_1, '0']
- [blocks_pack_k_bits_bb_0, '0', fec_ber_bf_0, '1']
- [blocks_pack_k_bits_bb_0_1, '0', fec_ber_bf_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_streams_to_vector_1, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_streams_to_vector_1, '1']
- [blocks_stream_to_vector_0_0_0, '0', blocks_udp_sink_1_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_udp_sink_1_0_0, '0']
- [blocks_streams_to_vector_1, '0', blocks_udp_sink_1, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_throttle_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [blocks_throttle_1, '0', channels_channel_model_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_delay_0_0, '0']
- [channels_channel_model_0, '0', channels_channel_model_0_1, '0']
- [channels_channel_model_0_0, '0', channels_channel_model_0_1_0, '0']
- [channels_channel_model_0_1, '0', virtual_sink_0, '0']
- [channels_channel_model_0_1_0, '0', virtual_sink_3_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_stream_to_vector_0, '0']
- [digital_binary_slicer_fb_0_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [digital_binary_slicer_fb_0_0_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [digital_cma_equalizer_cc_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0, '0']
- [digital_constellation_modulator_0, '0', osmosdr_sink_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_3, '0']
- [digital_costas_loop_cc_1, '0', blocks_multiply_const_vxx_0, '0']
- [digital_costas_loop_cc_1, '0', digital_cma_equalizer_cc_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_1, '0', analog_feedforward_agc_cc_1, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_1, '0', digital_costas_loop_cc_1, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [rational_resampler_xxx_1, '0', analog_pwr_squelch_xx_1, '0']
- [rational_resampler_xxx_1, '0', qtgui_sink_x_1, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_0, '0', qtgui_sink_x_1_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_1, '0']
- [virtual_source_1, '0', blocks_char_to_float_0, '0']
- [virtual_source_1, '0', blocks_pack_k_bits_bb_0_1, '0']
- [virtual_source_2, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [virtual_source_3, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_3_0, '0', blocks_complex_to_mag_squared_1, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_5, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_5_0, '0', blocks_complex_to_mag_squared_1_0, '0']

metadata:
  file_format: 1
